options:
  parameters:
    generate_options: qt_gui
    id: Raw
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/armaghan/Downloads/New Document.txt
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4000'
    scale: 1/1024
    type: float
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import time

      class snr_logger(gr.sync_block):
          def __init__(self, noise_power=1e-6):
              gr.sync_block.__init__(
                  self,
                  name="SNR Logger",
                  in_sig=[np.float32],  # average signal power
                  out_sig=[np.float32]  # SNR in dB
              )
              self.noise_power = noise_power
              self.log_file = open("snr_log.csv", "w")
              self.log_file.write("timestamp,snr_db\n")

          def work(self, input_items, output_items):
              powers = input_items[0]
              snrs = 10 * np.log10(powers / self.noise_power + 1e-10)
              output_items[0][:] = snrs

              for snr in snrs:
                  self.log_file.write(f"{time.time()},{snr}\n")
              self.log_file.flush()

              return len(output_items[0])
    noise_power: ''
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import pmt\nimport requests\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):  \n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name=\"LoRa Packet Receiver\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n\n        self.node_a_temp = None\n        self.node_a_hum = None\n        self.node_a_light = None\n        self.node_b_temp = None\n        self.node_b_hum = None\n        self.node_b_light = None\n\n        self.api_key = \"9IX44TQJ9WLVQ37V\"\n\n    def send_node_a_to_thingspeak(self):\n        payload = {\n            \"api_key\": self.api_key,\n            \"field1\": self.node_a_temp,\n            \"field2\": self.node_a_hum,\n            \"field3\": self.node_a_light\n        }\n        try:\n            response = requests.post(\"https://api.thingspeak.com/update\", data=payload, timeout=5)\n            if response.status_code == 200:\n                print(\"[ThingSpeak] Node A data sent.\")\n            else:\n                print(f\"[ThingSpeak] Node A failed. Status: {response.status_code}\")\n        except Exception as e:\n            print(f\"[ThingSpeak] Node A error: {e}\")\n\n    def send_node_b_to_thingspeak(self):\n        payload = {\n            \"api_key\": self.api_key,\n            \"field4\": self.node_b_temp,\n            \"field5\": self.node_b_hum,\n            \"field6\": self.node_b_light\n        }\n        try:\n            response = requests.post(\"https://api.thingspeak.com/update\", data=payload, timeout=5)\n            if response.status_code == 200:\n                print(\"[ThingSpeak] Node B data sent.\")\n            else:\n                print(f\"[ThingSpeak] Node B failed. Status: {response.status_code}\")\n        except Exception as e:\n            print(f\"[ThingSpeak] Node B error: {e}\")\n\n    def handle_msg(self, msg):\n        print(\">>> Python block received something!\")\n\n        try:\n            decoded = pmt.symbol_to_string(msg).strip()\n            print(f\"[LoRa Rx] Raw: {decoded}\")\n\n            parts = decoded.split()\n            i = 0\n            while i < len(parts) - 1:\n                if parts[i].endswith(\":\"):\n                    key = parts[i][:-1]\n                    val_str = parts[i+1]\n\n                    try:\n                        val = float(val_str)\n\n                        if key == \"NAT\":\n                            self.node_a_temp = val\n                            print(f\"[Node A] Temp: {val}\")\n                        elif key == \"NAH\":\n                            self.node_a_hum = val\n                            print(f\"[Node A] Hum: {val}\")\n                        elif key == \"NAL\":\n                            self.node_a_light = val\n                            print(f\"[Node A] Light: {val}\")\n                        elif key == \"NBT\":\n                            self.node_b_temp = val\n                            print(f\"[Node B] Temp: {val}\")\n                        elif key == \"NBH\":\n                            self.node_b_hum = val\n                            print(f\"[Node B] Hum: {val}\")\n                        elif key == \"NBL\":\n                            self.node_b_light = val\n                            print(f\"[Node B] Light: {val}\") \n                        else:\n                            print(f\"[LoRa Rx] Unknown key: {key}\")\n\n                    except ValueError:\n                        print(f\"[LoRa Rx] Invalid value for {key}: {val_str}\")\n                    i += 2\n                else:\n                    print(f\"[LoRa Rx] Unexpected token: {parts[i]}\")\n                    i += 1\n\n            # Send Node A data if both values are available\n            if self.node_a_temp is not None and self.node_a_hum is not None and self.node_a_light is not None:\n                self.send_node_a_to_thingspeak()\n                self.node_a_temp = None\n                self.node_a_hum = None\n                self.node_a_light = None\n\n\n            # Send Node B data if both values are available\n            if self.node_b_temp is not None and self.node_b_hum is not None and self.node_b_light is not None:\n                self.send_node_b_to_thingspeak()\n                self.node_b_temp = None\n                self.node_b_hum = None\n                self.node_b_light= None\n\n        except Exception as e:\n            print(f\"[LoRa Rx] Error: {e}\")\n\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: 'False'
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"SNR db"'
    type: float
    update_time: '10'
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '30'
    min: '-30'
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    gain0: '30'
    minoutbuf: int(np.ceil(samp_rate/bw*(2**sf+2)))
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_file_sink_1, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_1, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [lora_sdr_crc_verif_0, msg, epy_block_1, in]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', lora_sdr_frame_sync_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
